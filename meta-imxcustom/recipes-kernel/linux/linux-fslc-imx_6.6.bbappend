FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://0001-imx6ull-alientek-emmc-dtb.patch"
